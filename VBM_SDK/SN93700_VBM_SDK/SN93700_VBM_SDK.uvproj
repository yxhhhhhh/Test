# Keil uVision project SN93700_VBM_SDK.uvproj, settings and files
target SN93700_VBM_PU_HS_A7130 (ARM-ADS)
  device: SN93510 SONiX
  cpu: IRAM(0x200000-0x200FFF) IROM(0x100000-0x107FFF) CLOCK(204000000) CPUTYPE(ARM926EJ-S)
  output: SN93700_VBM_PU_HS_A7130
  AfterMake: fromelf --bin --output="$L@L.bin" "#L"
  AfterMake: .\UTILITY\Merge.bat @L 0x5351 2A000 16 20 1536
  c flags: Optim=1
  c define: _510PF_SDK_, RTOS, ASIC, HS_MODE, OP_AP,VBM_PU
  c misc: --c99
  c include: ..\COMMON_SRC\CMSIS;..\COMMON_SRC\CMSIS\rtos;..\COMMON_SRC\I2C;..\COMMON_SRC\CQI2C;..\COMMON_SRC\UART;..\COMMON_SRC\Timer;..\COMMON_SRC\BUF;..\COMMON_SRC\KNL;..\COMMON_SRC\RC;..\COMMON_SRC\OSD;..\COMMON_SRC\LCD;..\COMMON_SRC\INTC;..\COMMON_SRC\SEN;..\COMMON_SRC\SADC;..\COMMON_SRC\BSP;..\COMMON_SRC\WDT;..\COMMON_SRC\PAIR;..\COMMON_SRC\MEDIA;..\COMMON_SRC\AVI;..\COMMON_SRC\MP4;..\COMMON_SRC\CLI;..\COMMON_SRC\CLI\include;..\COMMON_SRC\VCS;..\COMMON_LIB\header;.\SRC\APP;.\SRC\UI;.\SRC\UI\HS;.\SRC\VDO;.\SRC\ADO;.\SRC\Boards;..\COMMON_SRC\APBC;..\COMMON_SRC\SPI;..\COMMON_SRC\Buzzer
  asm define: RTOS
  asm include: ..\COMMON_SRC\CMSIS\rtos
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x100000 size 0x100000
  scatter file: .\BIN\SN93700_VBM_PU_HS.sct
  group APP
    ./SRC/APP/: APP_HS.c
  group UI
    ./SRC/UI/HS/: UI.c UI_VBMBU.c UI_VBMPU.c UI_UART1.c UI_CMD.c
    ./SRC/UI/: KEY.c PKEY.c AKEY.c
  group CMSIS
    ../COMMON_SRC/CMSIS/: main.c system__510PF.c Retarget.c
    ../COMMON_SRC/CMSIS/startup/: startup_510PF.s
    ../COMMON_SRC/CMSIS/rtos/: RTOS.lib
  group System
    ../COMMON_LIB/: PROFILE.lib DDR.lib MMU.lib DMAC.lib RTC.lib
    ../COMMON_SRC/INTC/: INTC.c
    ../COMMON_SRC/Timer/: TIMER.c
    ../COMMON_SRC/WDT/: WDT.c
    ../COMMON_SRC/VCS/: VCS.c
    ../COMMON_SRC/APBC/: APBC.c
  group BSP
    ../COMMON_SRC/BSP/: BSP.c
    ./SRC/Boards/: BSP_Board.c BSP_Drivers.c
  group Miscellaneous
    ../COMMON_LIB/: CQ.lib SDIO.lib MC.lib
    ../COMMON_SRC/UART/: UART.c
    ../COMMON_SRC/I2C/: I2C.c
    ../COMMON_SRC/CQI2C/: CQI2C.c
    ../COMMON_SRC/SADC/: SADC.c
    ../COMMON_SRC/SPI/: SPI.c
    ../COMMON_SRC/Buzzer/: Buzzer.c
  group Kernel
    ../COMMON_SRC/KNL/: KNL.c
    ../COMMON_SRC/BUF/: BUF.c
  group BB/RF
    ../COMMON_LIB/: BB_AP.lib BB_STA.lib RF_A7130_AP.lib RF_A7130_STA.lib TWC_AP.lib TWC_STA.lib
    ../COMMON_SRC/PAIR/: PAIR.c
  group Storage
    ../COMMON_LIB/: SF.lib SD.lib FS.lib
  group Display
    ../COMMON_SRC/OSD/: OSD.c
    ../COMMON_SRC/LCD/: LCD.c LCD_GPM1125A0.c LCD_TM023KDH03.c LCD_TM024HDH03.c LCD_TM035KDH03.c LCD_SSD2828_Y50019N00N.c LCD_SSD2828.c LCD_SN9C271A.c LCD_TV.c LCD_HSD070IDW1.c
    ../COMMON_LIB/: HDMI.lib
  group CIPHER
    ../COMMON_LIB/: CIPHER.lib
  group Video Process/Codec
    ./SRC/VDO/: VDO.c
    ../COMMON_LIB/: H264.lib IMG.lib JPEG.lib
  group Audio
    ./SRC/ADO/: ADO.c
    ../COMMON_LIB/: ADO.lib
  group Image Sensor
    ../COMMON_SRC/SEN/: SEN.c AR0330.c OV9715.c OV9732.c H62.c H62_MIPI.c IMX323.c
  group Image Quality
    ../COMMON_LIB/: IQ.lib
    ../COMMON_SRC/IQ/: IQ_OPT_OV9715_RAW.C IQ_OPT_OV9732_RAW.c IQ_OPT_AR0330_RAW.c IQ_OPT_H62_RAW.c IQ_OPT_H62_MIPI_RAW.c IQ_OPT_IMX323_RAW.c
  group ISP
    ../COMMON_LIB/: ISP.lib
  group Rate Control
    ../COMMON_SRC/RC/: RC.c
  group FWU
    ../COMMON_LIB/: FWU.lib
  group USBD
    ../COMMON_LIB/: USBD.lib
  group USBH
    ../COMMON_LIB/: USBH.lib
  group CLI
    ../COMMON_SRC/CLI/: CLI.c
    ../COMMON_SRC/CLI/command/: cmd_h264.c cmd_printf.c cmd_vcs.c cmd_i2c.c cmd_isp.c cmd_sf.c cmd_system.c cmd_bb.c cmd_lcd.c cmd_mc.c cmd_ado.c cmd_ddr.c
target SN93700_VBM_BU_HS_A7130 (ARM-ADS)
  device: SN93510 SONiX
  cpu: as above
  output: SN93700_VBM_BU_HS_A7130
  AfterMake: fromelf --bin --output="$L@L.bin" "#L"
  AfterMake: .\UTILITY\Merge.bat @L 0x5351 2A000 16 20 1536
  c flags: Optim=1
  c define: _510PF_SDK_, RTOS, ASIC, HS_MODE, OP_STA, VBM_BU
  c misc: --c99
  c include: as above
  asm define: RTOS
  asm include: ..\COMMON_SRC\CMSIS\rtos
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x100000 size 0x100000
  scatter file: .\BIN\SN93700_VBM_BU_HS.sct
